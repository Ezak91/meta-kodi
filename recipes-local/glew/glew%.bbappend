PACKAGECONFIG = "egl-gles2"
